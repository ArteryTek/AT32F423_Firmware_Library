# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F423VCT7_v2 ArteryTek -AT32F423VCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F423VCT7; USE_STDPERIPH_DRIVER; AT_START_F423_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f423_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32f423_board/: at32f423_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f423.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f423.c
  group firmware
    ../../../../libraries/drivers/src/: at32f423_acc.c at32f423_adc.c at32f423_can.c at32f423_crc.c at32f423_crm.c at32f423_dac.c at32f423_debug.c at32f423_dma.c at32f423_ertc.c at32f423_exint.c at32f423_flash.c at32f423_gpio.c at32f423_i2c.c at32f423_misc.c at32f423_pwc.c at32f423_scfg.c at32f423_spi.c at32f423_tmr.c at32f423_usart.c at32f423_usb.c at32f423_wdt.c at32f423_wwdt.c at32f423_xmc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f423_clock.c at32f423_int.c main.c
