# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32F423VCT7_v2 ArteryTek -AT32F423VCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F423VCT7; USE_STDPERIPH_DRIVER; AT_START_F423_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f423_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F423xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f423_board/: at32f423_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f423.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f423.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f423_crm.c at32f423_flash.c at32f423_gpio.c at32f423_misc.c at32f423_tmr.c at32f423_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f423_clock.c at32f423_int.c iap.c main.c tmr.c usart.c
