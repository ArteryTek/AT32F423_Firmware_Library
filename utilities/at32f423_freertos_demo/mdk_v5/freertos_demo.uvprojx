# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F423VCT7 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F423VCT7,USE_STDPERIPH_DRIVER,AT_START_F423_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f423_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32f423_clock.c at32f423_int.c main.c include_port.c
  group bsp
    ../../../project/at32f423_board/: at32f423_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f423_acc.c at32f423_adc.c at32f423_can.c at32f423_crc.c at32f423_crm.c at32f423_dac.c at32f423_debug.c at32f423_dma.c at32f423_ertc.c at32f423_exint.c at32f423_flash.c at32f423_gpio.c at32f423_i2c.c at32f423_misc.c at32f423_pwc.c at32f423_scfg.c at32f423_spi.c at32f423_tmr.c at32f423_usart.c at32f423_usb.c at32f423_wdt.c at32f423_wwdt.c at32f423_xmc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f423.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f423.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: -AT32F423VCT7 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.0.0
  output: freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F423VCT7,USE_STDPERIPH_DRIVER,AT_START_F423_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f423_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
